Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Dryers-Hand-Hair_Jofel_Hand-dryer-high-speed-MINI-220-240V-50-6.ifc
Time: 2019-12-16T11:38:04
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Hand dryer high speed MINI 220-240V 50/60Hz
ePset_BIMobjectScript - Colour: AA56000 - White ABS; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Hand dryer high speed MINI 220-240V 50/60Hz; SKU (BO_prodsku): hand_dryer_mini_220-240V_50-60hz; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Hand dryers; ProductGroup (BO_prodgroup): AVE; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 167; Height (BO_height): 246; Depth (BO_depth): 148; Weight (BO_weight): 5; QR (BO_boqrurl): http://bimobject.com/jofel/product/hand_dryer_mini_220-240V_50-60hz; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/hand_dryer_mini_220-240V_50-60hz; MaterialMain (BO_mainmat): ABS; MaterialSecondary (BO_secmat): ABS; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Dryers (Hand & Hair); BimObjectCategoryCode (BO_bocat_code): sanitary-hand-and-hair-dryers; IfcClassification (BO_ifcclas): Electric Appliance; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L82421; Uniclass14Description (BO_uniclass_1_4_desc): Hand driers; Uniclass20Code (BO_uniclass_2_0_code): SS-60-80; Uniclass20Description (BO_uniclass_2_0_desc): Drying Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_62_37; Uniclass2015Description (BO_uniclass2015_desc): Hand driers; NBSReference (BO_nbs_ref): 60-80; NBSReferenceDescription (BO_nbs_desc): Drying Systems; OmniClassCode (BO_omniclass_code): 23-31 25 15; OmniClassDescription (BO_omniclass_name): Hand Dryers; MasterFormat2014Code (BO_masterformat2014_code): 10 28 13.13; MasterFormat2014Description (BO_masterformat2014_name): Commercial Toilet Accessories; UniFormat2Code (BO_uniformat2_code): E1090; UniFormat2Description (BO_uniformat2_name): Other Equipment; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, GF, GY, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW
